# Keil uVision project ROBOT.uvprojx, settings and files
target ROBOT (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ROBOT +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Lib\inc;.\System;.\USR
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c pbdata.c time.c WATCH_DOG.c OLED.c UI.c IO_CTRL.c AD_SENSOR.c remote.c LED.c
    ./stm32f10x_it/: stm32f10x_it.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c misc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
